# Keil uVision project FMC_MultiBoot.uvprojx, settings and files
target FMC_Boot0 (6240000::V6.24::ARMCLANG)
  device: M031LD2AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) IROM2(0x00100000,0x800) IROM3(0x00200000,0x200) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT0__
  c include: ..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x100000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M031Series_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ./: startup_M031Series_user.s
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c fmc.c sys.c timer.c uart.c
target FMC_Boot1 (6240000::V6.24::ARMCLANG)
  device: M031LD2AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: as above
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT1__
  c include: ..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x100000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: as above
target FMC_BootLD (6240000::V6.24::ARMCLANG)
  device: M031LD2AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: as above
  output: FMC_BootLD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __LDROM__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x100000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: as above
